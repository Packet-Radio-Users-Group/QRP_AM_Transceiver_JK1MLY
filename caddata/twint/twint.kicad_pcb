# Repository Packet-Radio-Users-Group/QRP_AM_Transceiver_JK1MLY (continued)

## KiCad design caddata/am-pcb2/am-pcb2.kicad_pcb

Parts:
C1, C6: 100u; CP_Radial_D7.5mm_P2.54mm_dot
C2, C3, C4, C5, C7, C8, C9, C11, C21, C32, C51, C52, C53, C55, C56, C58, C60, C62, C68, C69, C71, C76, C79, C84: 0.1u; C_Disc_P2.54mm
C12, C14, C16, C22, C31, C38, C41, C63, C77, C80, C86: 1000p; C_Disc_P2.54mm
C13, C17, C35, C36: 100p; C_Disc_P2.54mm
C15, C23, C24, C25, C64, C65, C66, C72: 33p; C_Disc_P2.54mm
C26, C67: 15p; C_Disc_P2.54mm
C33, C34: 150p; C_Disc_P2.54mm
C37: 1u; C_Disc_P2.54mm
C40, C49, C50: 10p; C_Disc_P2.54mm; not fitted
C42, C43, C44, C81, C82, C83: 220p; C_Disc_P2.54mm
C45, C46, C47, C48: 150p; C_Disc_P2.54mm; not fitted
C54, C57, C59, C61, C73, C74, C75, C78: 10u; C_Disc_P5.12mm
C85: 10p; C_Disc_P2.54mm
D21, D61: 1SV161; D_T-1_P5.08mm_Horizontal; not fitted
D81, D82: LED; LED_D3.0mm
D83, D84: 1N60; D_A-405_P2.54mm_Vertical_AnodeUp
IC51: UTC7642; TO-92_Inline_Wide
J1, J2: AudioJack2_Ground; Jack_3.5mm_CUI_SJ1-3525N_Horizontal
J3, J4: Conn_Coaxial; RF_SMA_Vertical_5-1814832-1
J81, J82, J83: Univ_03x05; univ_03x05
J85: Univ_04x08; univ_04x08
L11, L71: 100u; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
L21, L61: 10u; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical; not fitted
L22, L62: 100u; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical; not fitted
L41, L42, L81, L82: 15u; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
Q11: BF256B; TO-92_Inline_Wide
Q21, Q31, Q61, Q71: 2SC1959; TO-92_Inline_Wide
R11, R12, R14, R21, R22, R31, R61, R62: 100; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R13, R54, R76, R83: 100k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R15, R75: 22k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R23, R24, R63, R64, R71: 47k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R25, R65: 100; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical; not fitted
R26, R66: 1k; Potentiometer_1; not fitted
R27, R67: 10k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical; not fitted
R28, R68: 2.2k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R32: 15k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R33: 10k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R34: 220; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R52: 3.3k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R53, R73, R74: 10; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R55: 10k; Potentiometer_1
R72: 6.8k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R81, R82: 1k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
T1: 7T50; coil_7mm
T12, T71: 7S25; coil_7mm
T21, T61: 7T25; coil_7mm
T31: 7S1R0; coil_7mm
T41, T42: 7S1R0; coil_7mm; not fitted
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP13, TP14, TP23, TP24, TP25, TP33, TP34, TP43, TP44, TP53, TP54, TP63, TP64, TP73, TP74, TP75, TP76, TP81, TP82, TP83, TP84, TP85, TP86, TP87, TP88, TP91, TP92, TP93, TP94, TP95, TP96, TP97, TP98, TP99: TestPoint; TestPoint_Loop_D2.50mm_Drill1.0mm
TP41, TP42, TP45, TP46, TP47, TP48, TP49, TP50, TP51: TestPoint; TestPoint_pad_only_Drill1.0mm
U1: Microphone; Mic_CMA-4544PF-W
U51, U71: LM386; DIP-8_W7.62mm_Socket
U81: CF-455; CF-3P
X21: 27.000M; Crystal_HC49-U_Vertical
X61: 28.375M; Crystal_HC49-U_Vertical
Z1, Z2, Z3, Z4: TestPoint; TestPoint_Drill3mm

Connections:
+9V: C1.1, C2.1, C3.1, C4.1, C5.1, C11.1, C21.1, C32.1, C51.1, R11.1, R21.1, R25.1, R31.1, R53.1, R81.1, TP1.1, TP51.1
+9VA: C6.1, C7.1, C8.1, C9.1, C62.1, C71.2, R61.1, R65.1, R71.1, R74.1, R75.1, R82.1, TP11.1, TP50.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, C12.2, C15.2, C16.2, C21.2, C22.1, C25.2, C26.2, C31.2, C32.2, C37.2, C38.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C51.2, C52.2, C53.2, C54.2, C57.2, C58.1, C60.1, C62.2, C63.1, C66.2, C67.2, C68.1, C71.1, C74.2, C75.2, C77.2, C79.2, C81.2, C82.2, C83.2, C84.2, C86.2, D21.2 (A), D61.2 (A), D81.1 (K), D82.1 (K), D84.2 (A), IC51.1 (GND), J1.G, J2.G, J3.1 (G), J4.1 (G), J81.15, J82.6, J83.11, J85.1, J85.8, Q71.1 (E), R13.2, R14.1, R24.1, R26.3, R28.1, R33.1, R34.1, R55.1, R64.1, R66.3, R68.1, R72.1, R76.1, R83.2, T1.6 (G1), T1.7 (G2), T12.3 (PR2), T12.4 (S1), T12.6 (G1), T12.7 (G2), T21.4 (S1), T21.6 (G1), T21.7 (G2), T31.4 (S1), T31.6 (G1), T31.7 (G2), T41.3 (PR2), T41.6 (G1), T41.7 (G2), T42.3 (PR2), T42.6 (G1), T42.7 (G2), T61.4 (S1), T61.6 (G1), T61.7 (G2), T71.5 (S1), T71.6 (G1), T71.7 (G2), TP2.1, TP4.1, TP6.1, TP8.1, TP10.1, TP81.1, TP82.1, TP85.1, TP86.1, TP87.1, TP88.1, TP91.1, TP92.1, TP93.1, TP94.1, TP95.1, TP96.1, TP97.1, TP98.1, TP99.1, U1.1 (-), U51.2 (-), U51.4 (GND), U71.2 (-), U71.4 (GND), U81.2 (GND), Z1.1, Z2.1, Z3.1, Z4.1
unnamed: C12.1, L11.1, R11.2, R15.1
unnamed: C13.1, R12.1
unnamed: C17.2, TP25.1
unnamed: C26.1, L21.1, X21.1
unnamed: C35.1, TP14.1
unnamed: C36.1, R22.1
unnamed: C40.1, C41.1, TP34.1
unnamed: C41.2, C42.1, C50.1, L41.1
unnamed: C43.1, L41.2, L42.1
unnamed: C44.1, L42.2, TP43.1
unnamed: C52.1, R52.1, TP54.1
unnamed: C55.1, TP44.1
unnamed: C56.2, R55.3
unnamed: C59.1, C68.2, U51.5
unnamed: C59.2, TP5.1, TP49.1
unnamed: C61.1, U51.1 (GAIN)
unnamed: C61.2, U51.8 (GAIN)
unnamed: C67.1, L61.1, X61.1
unnamed: C73.1, C79.1, R73.2, U71.5
unnamed: C73.2, L71.2, R73.1
unnamed: C76.1, R75.2, TP7.1
unnamed: C78.1, U71.1 (GAIN)
unnamed: C78.2, U71.8 (GAIN)
unnamed: C80.1, R62.2
unnamed: C81.1, L81.1, TP74.1
unnamed: C82.1, L81.2, L82.1
unnamed: C83.1, L82.2, TP9.1
unnamed: C85.1, TP75.1
unnamed: D21.1 (K), L21.2, L22.2
unnamed: D61.1 (K), L61.2, L62.2
unnamed: C84.1, D81.2 (A), R81.2, TP53.1
unnamed: D82.2 (A), R82.2
unnamed: C85.2, D83.2 (A)
unnamed: C86.1, D83.1 (K), D84.1 (K), R83.1, TP76.1
unnamed: C55.2, IC51.2 (IN), R54.2
unnamed: C56.1, C58.2, IC51.3 (OUT), R52.2, R54.1
unnamed: J1.S, TP48.1
unnamed: J1.T, TP41.1
unnamed: J2.T, TP42.1
unnamed: J3.2 (S), TP45.1
unnamed: J4.2 (S), TP46.1
unnamed: L22.1, R27.2
unnamed: L62.1, R67.2
unnamed: C13.2, L11.2, Q11.3 (D)
unnamed: C14.2, Q11.1 (G), R13.1, R15.2
unnamed: C16.1, Q11.2 (S), R14.2
unnamed: C24.1, Q21.3 (B), R23.2, R24.2, X21.2
unnamed: C23.2, Q21.2 (C), T21.3 (PR2)
unnamed: C24.2, C25.1, Q21.1 (E), R28.2
unnamed: C35.2, C36.2, Q31.3 (B), R32.2, R33.2
unnamed: C33.2, C34.2, Q31.2 (C), T31.3 (PR2)
unnamed: C17.1, C37.1, Q31.1 (E), R34.2
unnamed: C65.1, Q61.3 (B), R63.2, R64.2, X61.2
unnamed: C64.2, Q61.2 (C), T61.3 (PR2)
unnamed: C65.2, C66.1, Q61.1 (E), R68.2
unnamed: C80.2, Q71.3 (B), R71.2, R72.2
unnamed: C72.1, Q71.2 (C), T71.3 (PR1)
unnamed: R12.2, TP13.1
unnamed: R22.2, TP24.1
unnamed: R25.2, R26.1
unnamed: R26.2, R27.1
unnamed: R62.1, TP64.1
unnamed: R65.2, R66.1
unnamed: R66.2, R67.1
unnamed: C14.1, C15.1, T12.1 (PR1)
unnamed: T12.5 (S2), TP3.1
unnamed: C22.2, R21.2, R23.1, T21.2 (PM)
unnamed: C23.1, T21.1 (PR1)
unnamed: T21.5 (S2), TP23.1
unnamed: C31.1, R31.2, R32.1, T31.2 (PM)
unnamed: C33.1, C34.1, C38.1, T31.1 (PR1)
unnamed: T31.5 (S2), TP33.1
unnamed: C40.2, C45.1, C46.1, C49.1, T41.1 (PR1)
unnamed: C47.1, C48.1, C49.2, C50.2, T42.1 (PR1)
unnamed: C63.2, R61.2, R63.1, T61.2 (PM)
unnamed: C64.1, T61.1 (PR1)
unnamed: T61.5 (S2), TP63.1
unnamed: C72.2, T71.1 (PR2)
unnamed: T71.4 (S2), TP73.1
unnamed: TP47.1, U1.2 (+)
unnamed: C60.2, R55.2, U51.3 (+)
unnamed: C57.1, U51.7 (BYPASS)
unnamed: C76.2, C77.1, R76.2, U71.3 (+)
unnamed: C75.1, U71.7 (BYPASS)
unnamed: C74.1, R74.2, U71.6 (V+)
unnamed: TP83.1, U81.1 (IN)
unnamed: TP84.1, U81.3 (OUT)

Notes on the sheet:
50M 7T1R0 300p 1.7M 16.9344*3 -16.384*3 = 1.6512 28M 7T1R0 370p 1.4M 28.375-27.000 = 1.375
R73 微弱 220 10mW 10
Drill=3.2mm Wire=0.4mm Length=5.12mm r=1.8-1.9 Turn 9 = 153-169n Turn 11 = 230-253n Turn 13 = 321-353n
2M chebyshev 3300p,4.7u,4700p,4.7u,3300p 3M chebyshev 2200p,3.3u,3300p,3.3u,2200p 2M butterworth 1000p,6.8u,3300p,6.8u,1000p 3M butterworth 680p,4.7u,2200p,4.7u,680p
Drill=3.2mm Wire=0.2mm Length=2.54mm r=1.7-1.8 Turn 7 = 136-150n Turn 9 = 226-248n Turn 11 = 338-371n
50M 7T50 10p 2SC1923 16.9344M x 3 28M 7T25 33p 2SC1959 28.375M
35M chebyshev 150p,330n,330p,330n,150p 60M chebyshev 82p,150n,120p,150n,82p 35M butterworth 56p,330n,180p,330n,56p 60M butterworth 33p,220n,100p,220n,33p
50M 7T50 10p 2SC1923 16.384M x 3 28M 7T25 33p 2SC1959 27.000M

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
Board: 2 copper layers, 99.7 x 96.5 mm, 215 parts (0 on the bottom side), 92 nets.

## Commit log

2024-07-14 Add files
    KICADデータ2種am-pcb1と3を追加
2024-07-14 Add files
2024-07-18 step-by-step.txt を更新
2024-07-29 update
    add am-pcb2 ,4
